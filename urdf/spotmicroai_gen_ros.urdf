Commit message: removed lidar

File: urdf/spotmicroai_gen_ros.urdf (robot description, URDF)
Before this commit: robot SpotMicroAI, 24 links, 23 joints
Links:
- removed link lidar_link
Joints:
- removed joint base_lidar
